Commit message: Modified timeout value of magswitch

File: aist_description/devices/urdf/rs007l.urdf (robot description, URDF)
Before this commit: robot aaa, 1 links, 0 joints
Links:
- removed link base_link
- added link world
